# Keil uVision project wolfsslFull.uvprojx, settings and files
target STM32F207 Flash (ARM-ADS)
  device: STM32F207IGHx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: wolfssl-Full
  c flags: Optim=4 uC99=1 wLevel=2
  c define: HSE_VALUE=25000000 HAVE_CONFIG_H  MDK_CONF_full WOLFSSL_USER_SETTINGS
  c misc: --diag_suppress=1293
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source
    ./: main.c shell.c time-CortexM3-4.c
  group Configuration
    ./RTE/wolfSSL/: config-Crypt.h config-wolfSSL.h
    ../../Conf/: user_settings.h
  group Documentation
    ./: Abstract.txt
software components: CMSIS:CORE 4.1.0, CMSIS:RTOS:Keil RTX 4.78.0, Network:CORE 7.0.0, Network:Interface:ETH 7.0.0, Network:Service:DNS Client 7.0.0, Network:Socket:BSD 7.0.0, Network:Socket:TCP 7.0.0, Network:Socket:UDP 7.0.0, File System:CORE 6.5.0, File System:Drive:Memory Card 6.5.0, CMSIS Driver:Ethernet MAC 2.01, CMSIS Driver:Ethernet PHY:ST802RT1 6.00, CMSIS Driver:MCI 2.02, Compiler:I/O:File 1.0.0, Compiler:I/O:STDERR 1.0.0, Compiler:I/O:STDIN 1.0.0, Compiler:I/O:STDOUT 1.0.0, Device:STM32Cube Framework:Classic 1.0.1, Device:STM32Cube HAL:Common 1.0.1, Device:STM32Cube HAL:Cortex 1.0.1, Device:STM32Cube HAL:DMA 1.0.1, Device:STM32Cube HAL:GPIO 1.0.1, Device:STM32Cube HAL:RCC 1.0.1, Device:STM32Cube HAL:SRAM 1.0.1, Device:Startup 2.0.1, wolfSSL:wolfCrypt:Benchmark , wolfSSL:wolfCrypt:CORE , wolfSSL:wolfCrypt:Test , wolfSSL:wolfSSL:Core , wolfSSL:wolfSSL:SimpleClient , wolfSSL:wolfSSL:SimpleServer , wolfSSL:wolfSSL:echoClient , wolfSSL:wolfSSL:echoServer 
